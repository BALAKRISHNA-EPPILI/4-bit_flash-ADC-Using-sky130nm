* C:\Users\vansh\Downloads\priority_encoder\priority_encoder.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 3/5/2022 4:08:28 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U13  I0 I1 I2 I3 I4 I5 I6 I7 Net-_U13-Pad9_ Net-_U13-Pad10_ Net-_U13-Pad11_ Net-_U13-Pad12_ Net-_U13-Pad13_ Net-_U13-Pad14_ Net-_U13-Pad15_ Net-_U13-Pad16_ adc_bridge_8
v1  I0 I15 pulse
v2  I1 I15 pulse
v3  I2 I15 pulse
v4  I3 I15 pulse
v5  I4 I15 pulse
v6  I5 I15 pulse
v7  I6 I15 pulse
v8  I7 I15 pulse
U1  I0 plot_v1
U2  I1 plot_v1
U3  I2 plot_v1
U4  I3 plot_v1
U5  I4 plot_v1
U8  I7 plot_v1
U7  I6 plot_v1
U6  I5 plot_v1
U9  O0 plot_v1
U10  O1 plot_v1
U11  O2 plot_v1
R3  Net-_R3-Pad1_ O2 1k
R2  Net-_R2-Pad1_ O1 1k
R1  Net-_R1-Pad1_ O0 1k
U21  Net-_U13-Pad9_ Net-_U13-Pad10_ Net-_U13-Pad11_ Net-_U13-Pad12_ Net-_U13-Pad13_ Net-_U13-Pad14_ Net-_U13-Pad15_ Net-_U13-Pad16_ Net-_U21-Pad9_ Net-_U21-Pad10_ Net-_U21-Pad11_ Net-_U21-Pad12_ Net-_U21-Pad13_ Net-_U21-Pad14_ Net-_U21-Pad15_ Net-_U21-Pad16_ Net-_U21-Pad17_ Net-_U21-Pad18_ Net-_U21-Pad19_ Net-_U21-Pad20_ bala_priority_encoder
U22  Net-_U21-Pad17_ Net-_U21-Pad18_ Net-_U21-Pad19_ Net-_U21-Pad20_ Net-_R1-Pad1_ Net-_R2-Pad1_ Net-_R3-Pad1_ Net-_R4-Pad1_ dac_bridge_4
R4  Net-_R4-Pad1_ O3 1k
U12  O3 plot_v1
v9  I8 I15 pulse
v10  I9 I15 pulse
v11  I10 I15 pulse
v12  I11 I15 pulse
v13  I12 I15 pulse
v14  I13 I15 pulse
v15  I14 I15 pulse
v16  Net-_U23-Pad7_ I15 pulse
Ua1  I8 plot_v1
U14  I9 plot_v1
U15  I10 plot_v1
U16  I11 plot_v1
U17  I12 plot_v1
U18  I13 plot_v1
U19  I14 plot_v1
U20  I15 plot_v1
U23  I8 I9 I10 I11 I12 I13 Net-_U23-Pad7_ I14 Net-_U21-Pad9_ Net-_U21-Pad10_ Net-_U21-Pad11_ Net-_U21-Pad12_ Net-_U21-Pad13_ Net-_U21-Pad14_ Net-_U21-Pad15_ Net-_U21-Pad16_ adc_bridge_8

.end
